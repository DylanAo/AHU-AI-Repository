DATA SEGMENT
    FLAG DB 0
    A DB 'QWERT'
    B DB 'QWERT'
DATA ENDS

CODE SEGMENT
    ASSUME CS:CODE,DS:DATA,ES:DATA

START:
    MOV AX,DATA
    MOV DS,AX
    MOV ES,AX
    XOR AX,AX

    LEA SI,A
    LEA DI,B
    MOV CX,5
    REP CMPSB 

    CMP CX,0
    JA ABOVE
    MOV FLAG,1
    JMP EXIT
ABOVE:
    MOV FLAG,0
    
EXIT:
    MOV AH,4CH
    INT 21H
CODE ENDS
END START