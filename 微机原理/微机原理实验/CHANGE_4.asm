DATA SEGMENT
    ORG 1
    STRING DB "1Aa2Bc"
DATA ENDS

CODE SEGMENT
    ASSUME CS:CODE,DS:DATA

START:
    MOV AX,DATA
    MOV DS,AX
    XOR AX,AX

    MOV BX,OFFSET STRING - 1
AGAIN:
    INC BX
    CMP BX,7
    JE OVER

    CMP BYTE PTR[BX],"A"
    JB AGAIN
    CMP BYTE PTR[BX],"Z"
    JA AGAIN
    OR BYTE PTR[BX],20H
    JMP AGAIN
OVER:
    MOV AH,4CH
    INT 21H
CODE ENDS
END START